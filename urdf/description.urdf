Commit message: Versão 1.0

File: urdf/description.urdf (robot description, URDF)
Before this commit: robot description, 6 links, 5 joints
Joints:
- joint sensor_joint_right: origin xyz=0.0 0.22 0.12 rpy=0.1 +0.8 1.75 -> xyz=0.0 0.22 0.12 rpy=0 0 1.57079633
